IMAGE_INSTALL:append = " hello network-monitor"
