S = "${WORKDIR}"
LIC_FILES_CHKSUM ?= "file://LICENSE;md5=57d76440fc5c9183c79d1747d18d2410"
SRC_URI += "file://LICENSE"

